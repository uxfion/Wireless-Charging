# Keil uVision project Energy.uvproj, settings and files
target ENERGY (MCS-51)
  device: STC8A8K64S4A12 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: Energy +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Core;.\Lib\MY;.\Lib\STC8;.\Lib\ZF;.\User
  group CORE
    ./Core/: STARTUP.A51 STC8Axx.h board.h board.c common.h common.c SEEKFREE_PRINTF.h SEEKFREE_PRINTF.c
  group STC8_H
    ./Lib/STC8/: STC8_adc.h STC8_delay.h STC8_eeprom.h STC8_exti.h STC8_gpio.h STC8_iic.h STC8_pca_delay.h STC8_pca_pit.h STC8_pwm.h STC8_tim.h STC8_uart.h STC8_nvic.h
  group STC8_C
    ./Lib/STC8/: STC8_adc.c STC8_delay.c STC8_eeprom.c STC8_exti.c STC8_gpio.c STC8_iic.c STC8_pca_delay.c STC8_pca_pit.c STC8_pwm.c STC8_tim.c STC8_uart.c STC8_nvic.c
  group MY_H
    ./Lib/MY/: MY_spi.h MY_oled.h MY_control.h MY_pid.h VCAN_computer.h MY_mpu6050.h MY_iic.h MY_delay.h inv_mpu_dmp_motion_driver.h inv_mpu.h dmpmap.h dmpKey.h process.h MY_tlc5615.h MY_charge.h MY_eeprom.h
  group MY_C
    ./Lib/MY/: MY_spi.c MY_oled.c MY_control.c MY_pid.c VCAN_computer.c MY_mpu6050.c MY_iic.c MY_delay.c inv_mpu_dmp_motion_driver.c inv_mpu.c process.c MY_tlc5615.c MY_charge.c MY_eeprom.c
  group USER
    ./User/: headfile.h main.c isr.h isr.c pin_cfg.h
